	moveal #0x99c4,%a7
	moveal #0x8994,%a0
	moveal #0x89c4,%a1
	cmpal %a0,%a1
	beqs .+6
	clrl %a0@+
	bras .-6
	jsr 0x802c:l
	trap #0
	stop #9984
	braw .-4
	.short 0x0000, 0x4ef9
	.short 0x0000, 0x847e
	.short 0x0000, 0x60fe
	bras .
	movel %a2,%a7@-
	movel %d2,%a7@-
	moveal %a7@(12:w),%a0
	clrw %d0
	subal %a1,%a1
	leal 0x850e:l,%a2
	cmpal %a7@(16:w),%a1
	blts .+8
	movel %a7@+,%d2
	moveal %a7@+,%a2
	rts
	movew %d0,%d1
	lsrw #8,%d1
	moveb %a0@(0,%a1:l),%d2
	eorb %d2,%d1
	andil #255,%d1
	addl %d1,%d1
	lslw #8,%d0
	movew %a2@(0,%d1:l),%d1
	eorw %d1,%d0
	addql #0x1,%a1
	bras .-40
	subql #0x4,%a7
	moveql #0,%d0
	movel %d0,%a7@
	movel %a7@,%d0
	cmpl %a7@(8:w),%d0
	bcss .+6
	addql #0x4,%a7
	rts
	movel %a7@,%d0
	addql #1,%d0
	bras .-18
	movel %a7@(4:w),%d0
	movel %d0,%d1
	addl %a7@(12:w),%d1
	moveal %d0,%a0
	cmpl %a0,%d1
	bnes .+4
	rts
	moveb %a7@(11:w),%a0@+
	bras .-10
	moveaw #0x4306,%a1
	moveb #-125,%a1@
	moveb #8,0x4300:w
	moveaw #0x4302,%a0
	moveb #0,%a0@
	moveb #3,%a1@
	moveb #-57,0x4304:w
	moveb #0,0x4308:w
	moveb #0,%a0@
	rts
	moveb 0x430a:w,%d0
	btstl #0,%d0
	beqs .-8
	moveb 0x4300:w,%d0
	rts
	bras .-16
	movel %a7@(4:w),%d0
	moveb 0x430a:w,%d1
	btstl #5,%d1
	beqs .-8
	moveb %d0,0x4300:w
	rts
	moveml %d2-%d4/%a2,%a7@-
	leal %pc@(-44:w),%a2
	jsr %a2@
	moveb %d0,0x8995:l
	jsr %a2@
	moveb %d0,%d2
	moveb %d0,0x8996:l
	cmpib #8,%d0
	blss .+32
	moveql #0,%d4
	moveb %d0,%d4
	moveql #0,%d3
	jsr %a2@
	addql #1,%d3
	cmpl %d3,%d4
	bgts .-6
	moveql #0,%d3
	andil #255,%d2
	cmpl %d2,%d3
	blts .+46
	clrb %d0
	bras .+36
	cmpib #8,%d0
	bnes .-20
	moveql #0,%d2
	jsr %a2@
	leal 0x89b0:l,%a0
	moveb %d0,%a0@(0,%d2:l)
	addql #1,%d2
	moveql #8,%d0
	cmpl %d2,%d0
	bnes .-18
	moveb 0x89b2:l,%d0
	moveml %a7@+,%d2-%d4/%a2
	rts
	jsr %a2@
	addql #1,%d3
	bras .-52
	moveml %d2-%d3/%a2,%a7@-
	leal %pc@(-152:w),%a2
	jsr %a2@
	moveb %d0,0x8996:l
	moveql #0,%d3
	moveql #0,%d2
	moveb %d0,%d2
	cmpl %d2,%d3
	blts .+8
	moveml %a7@+,%d2-%d3/%a2
	rts
	jsr %a2@
	addql #1,%d3
	bras .-14
	leal %a7@(-12:w),%a7
	movel %d2,%a7@-
	moveb #87,%a7@(5:w)
	moveb #-85,%a7@(6:w)
	moveb #18,%a7@(7:w)
	clrb %a7@(8:w)
	clrb %a7@(9:w)
	clrb %a7@(10:w)
	clrb %a7@(11:w)
	moveb %a7@(23:w),%a7@(12:w)
	clrb %a7@(13:w)
	moveb #15,%a7@(14:w)
	moveql #2,%d0
	clrb %d1
	addb %a7@(5,%d0:l),%d1
	addql #1,%d0
	moveql #10,%d2
	cmpl %d0,%d2
	bnes .-10
	moveb %d1,%a7@(15:w)
	moveql #0,%d0
	moveb 0x430a:w,%d1
	btstl #5,%d1
	beqs .-8
	moveb %a7@(5,%d0:l),0x4300:w
	addql #1,%d0
	moveql #11,%d1
	cmpl %d0,%d1
	bnes .-22
	movel %a7@+,%d2
	leal %a7@(12:w),%a7
	rts
	moveml %d2-%d3/%a2-%a4,%a7@-
	leal %pc@(-300:w),%a2
	jsr %a2@
	moveql #1,%d2
	moveql #0,%d3
	moveb %d0,%d3
	leal 0x8998:l,%a3
	leal 0x89a4:l,%a4
	moveb 0x8994:l,%d0
	cmpl %d3,%d2
	blts .+84
	tstb %d0
	bnes .+74
	moveb #1,0x8994:l
	cmpib #2,0x89a6:l
	bnes .+10
	moveb #2,0x89bd:l
	cmpib #57,0x89a8:l
	bnes .+38
	leal %pc@(-190:w),%a0
	tstb 0x89bc:l
	bnes .+54
	moveb #2,0x89bd:l
	peal 0x2:w
	jsr %a0@
	moveb #1,0x89bc:l
	addql #0x4,%a7
	moveml %a7@+,%d2-%d3/%a2-%a4
	rts
	tstb %d0
	bnes .+12
	jsr %a2@
	moveb %d0,%a4@(0,%d2:l)
	addql #1,%d2
	bras .-104
	jsr %a2@
	moveb %d0,%a3@(0,%d2:l)
	bras .-10
	clrb 0x89bd:l
	clrl %a7@-
	jsr %a0@
	clrb 0x89bc:l
	bras .-46
	moveml %a2-%a5,%a7@-
	leal %pc@(-460:w),%a2
	leal %pc@(-170:w),%a3
	leal %pc@(-322:w),%a4
	jsr %a2@
	cmpib #87,%d0
	beqs .+10
	clrb 0x8994:l
	bras .-14
	jsr %a2@
	cmpib #-85,%d0
	bnes .-22
	jsr %a2@
	moveb %d0,0x8997:l
	cmpib #-127,%d0
	bnes .+6
	jsr %pc@(-472:w)
	moveb 0x8997:l,%d0
	cmpib #-126,%d0
	beqs .-52
	cmpib #-121,%d0
	bnes .+4
	jsr %a4@
	cmpib #-120,0x8997:l
	bnes .+4
	jsr %a3@
	cmpib #1,0x8994:l
	bnes .-82
	clrb %d0
	moveml %a7@+,%a2-%a5
	rts
	jmp 0x0:l
	rts
	subql #0x8,%a7
	movel %a6,%a7@-
	leal %a7@(7:w),%a6
	peal 0x5:w
	peal 0x870e:l
	movel %a6,%a7@-
	jsr 0x84f0:l
	leal %a7@(12:w),%a7
	moveql #0,%d0
	moveb 0x430a:w,%d1
	btstl #5,%d1
	beqs .-8
	moveb %a6@(0,%d0:l),0x4300:w
	addql #1,%d0
	moveql #5,%d1
	cmpl %d0,%d1
	bnes .-22
	moveal %a7@+,%a6
	addql #0x8,%a7
	rts
	linkw %a6,#0xfffffd80
	movel %d3,%a7@-
	movel %d2,%a7@-
	movel %a6@(12:w),%d2
	moveb %a6@(11:w),%d3
	peal 0x80:w
	peal 0x8713:l
	peal %a6@(-640:w)
	jsr 0x84f0:l
	peal 0x80:w
	peal 0x8793:l
	peal %a6@(-512:w)
	jsr 0x84f0:l
	peal 0x80:w
	peal 0x8813:l
	peal %a6@(-384:w)
	jsr 0x84f0:l
	leal %a7@(36:w),%a7
	peal 0x80:w
	peal 0x8893:l
	peal %a6@(-256:w)
	jsr 0x84f0:l
	peal 0x80:w
	peal 0x8913:l
	peal %a6@(-128:w)
	jsr 0x84f0:l
	leal %a7@(24:w),%a7
	tstb %d3
	bnes .+54
	andil #255,%d2
	leal %a6@(0,%d2:l),%a0
	moveb %a0@(-640:w),%d0
	cmpib #2,0x89bc:l
	bnes .+18
	moveb %d0,%d1
	addib #-97,%d1
	cmpib #25,%d1
	bhis .+6
	addib #-32,%d0
	movel %a6@(-648:w),%d2
	movel %a6@(-644:w),%d3
	unlk %a6
	rts
	cmpib #2,%d3
	beqs .+8
	cmpib #32,%d3
	bnes .+44
	andil #255,%d2
	leal %a6@(0,%d2:l),%a0
	moveb %a0@(-512:w),%d0
	cmpib #2,0x89bc:l
	bnes .-46
	moveb %d0,%d1
	addib #-65,%d1
	cmpib #25,%d1
	bhis .-58
	addib #32,%d0
	bras .-64
	cmpib #1,%d3
	bnes .+18
	andil #255,%d2
	leal %a6@(0,%d2:l),%a0
	moveb %a0@(-384:w),%d0
	bras .-86
	cmpib #16,%d3
	beqs .-20
	cmpib #4,%d3
	bnes .+18
	andil #255,%d2
	leal %a6@(0,%d2:l),%a0
	moveb %a0@(-256:w),%d0
	bras .-114
	cmpib #64,%d3
	bnes .+16
	andil #255,%d2
	moveb %a6@(-128,%d2:l),%d0
	braw .-132
	clrb %d0
	braw .-138
	movel %a2,%a7@-
	movel %d2,%a7@-
	jsr %pc@(-494:w)
	moveql #0,%d0
	moveb 0x89a8:l,%d0
	movel %d0,%a7@-
	moveb 0x89bd:l,%d0
	extw %d0
	moveaw %d0,%a0
	movel %a0,%a7@-
	jsr %pc@(-342:w)
	addql #0x8,%a7
	moveb %d0,%d2
	cmpib #27,%d0
	bnes .+28
	jsr %pc@(-426:w)
	tstb 0x89bc:l
	bnes .+8
	clrb 0x89bd:l
	moveb %d2,%d0
	movel %a7@+,%d2
	moveal %a7@+,%a2
	rts
	cmpib #31,%d0
	blss .-26
	peal 0xc:w
	clrl %a7@-
	peal 0x89a4:l
	leal %pc@(-1100:w),%a2
	jsr %a2@
	peal 0xc:w
	clrl %a7@-
	peal 0x8998:l
	jsr %a2@
	leal %a7@(24:w),%a7
	bras .-64
	movel %a7@(4:w),%d0
	moveal %a7@(8:w),%a0
	moveql #0,%d1
	cmpl %a7@(12:w),%d1
	bnes .+4
	rts
	moveal %d0,%a1
	moveb %a0@(0,%d1:l),%a1@(0,%d1:l)
	addql #1,%d1
	bras .-18
	.short 0x0000, 0x1021
	moveal %d2,%a0
	moveaw %a3@-,%a0
	negxl %d4
	addql #8,%a5@-
	bras .-56
	moveql #-25,%d0
	sbcdb %a0@-,%a0@-
	subb %d0,%a1@(-24246:w)
	eorw %d0,%a3@(-15988:w)
	addl %d0,%a5@(-7730:w)
	.short 0xf1ef
	.short 0x1231
	.short 0x0210, 0x3273
	moveal %a2@,%a1
	.short 0x52b5
	clrl %a4@
	moveql #-9,%d1
	bhis .-40
	subb %d1,0x8318b37b:l
	.short 0xa35a
	.short 0xd3bd
	andl %d1,%a4@+
	.short 0xf3ff
	lslw %a6@+
	moveal %a2@-,%a2
	moveaw %d3,%a2
	.short 0x0420, 0x1401
	bccs .-24
	moveql #-57,%d2
	negl %a4@-
	addql #2,%d5
	.short 0xa56a
	cmpmw %a3@+,%a2@+
	orb %d2,%a0@(-27383:w)
	roxlw %a6@(-2609:w)
	andl %d2,%a4@(-10867:w)
	moveaw %a3@,%a3
	.short 0x2672
	moveb %a1@,%d3
	.short 0x0630
	moveql #-41,%d3
	bnes .-8
	addql #3,%a5@
	.short 0x46b4
	eorw %d3,%a3@+
	.short 0xa77a
	subb %d3,%a1@+
	orb %d3,0xfffff7df:w
	.short 0xe7fe
	addl %d3,%a5@+
	.short 0xc7bc
	extl %d4
	svcb %a5@-
	bvcs .-120
	moveql #-89,%d4
	.short 0x0840, 0x1861
	movel %d2,%d4
	movew %a3@-,%d4
	.short 0xc9cc
	addal %a5@(-5746:w),%a4
	.short 0xf9af
	.short 0x8948
	subw %d4,%a1@(-22262:w)
	eorb %d4,%a3@(23285:w)
	tasb %a4@
	moveql #-73,%d5
	bpls .-104
	.short 0x1a71
	eoriw #14899,%a0@
	movel %a2@,%d5
	.short 0xdbfd
	mulsw %a4@+,%d5
	.short 0xfbbf
	roll #5,%d6
	subw %d5,0x8b58bb3b:l
	.short 0xab1a
	bges .-88
	moveql #-121,%d6
	.short 0x4ce4
	sgeb %d5
	movel %a2@-,%d6
	movew %d3,%d6
	cmpiw #7233,%a0@-
	lsll %d6,%d6
	.short 0xfd8f
	mulsw %a4@(-8755:w),%d6
	.short 0xad2a
	cmpmb %a3@+,%a6@+
	orw %d6,%a0@(-25271:w)
	moveql #-105,%d7
	bgts .-72
	sgtb %a5@
	.short 0x4ef4
	movew %a3@,%d7
	.short 0x2e32
	.short 0x1e51
	.short 0x0e70
	.short 0xff9f
	roll %d7,%d6
	addal %a5@+,%a7
	mulsw #-16613,%d7
	.short 0xaf3a
	subw %d7,%a1@+
	orw %d7,0xffff9188:w
	orl %d0,%a1@(-20022:w)
	.short 0xa1eb
	addxb %a4@-,%a0@-
	andb %d0,%a5@(-3762:w)
	lslw %d0,%d7
	moveb %d0,%a0@
	oril #818028771,%a1@-
	addqb #8,%d4
	negxb %a5@-
	moveql #70,%d0
	bras .+105
	orl %d1,0x9398a3fb:l
	cmpal %a2@+,%a1
	.short 0xc33d
	addb %d1,%a4@+
	rolw %d1,%d7
	.short 0xf35e
	.short 0x02b1
	moveb %a0@,%a1@
	.short 0x22f3
	movew %a2@,%a1@+
	.short 0x4235
	addqb #1,%a4@
	bhis .+121
	moveql #86,%d1
	cmpal %a2@(-23093:w),%a2
	subl %d2,%a0@(-31351:w)
	.short 0xf56e
	lslw #2,%d7
	addb %d2,%a4@(-15091:w)
	movew %a2@-,%a2@+
	movel %d3,%a2@+
	moveb %a0@-,%a2@
	subil #1952867399,%d1
	addqb #2,%a4@-
	negb %d5
	.short 0xa7db
	cmpal %pc@(-30823:w),%a3
	subl %d3,0xffffe75f:w
	.short 0xf77e
	andb %d3,%a5@+
	.short 0xd73c
	movel %a3@,%a3@+
	.short 0x36f2
	addil #380659287,%a1@
	moveql #118,%d3
	notb %a5@
	.short 0x5634
	addxw %a4@-,%a4@-
	andw %d4,%a5@(-1778:w)
	lslb %d4,%d7
	subal %a0,%a4
	divsw %a1@(-18038:w),%d4
	.short 0xa9ab
	addqw #4,%d4
	.short 0x4865
	moveql #6,%d4
	bvcs .+41
	moveb %d0,%a4@+
	.short 0x08e1, 0x3882
	movel %a3@-,%a4@
	.short 0xcb7d
	addw %d5,%a4@+
	rolb %d5,%d7
	.short 0xfb1e
	divsw 0x9bd8abbb:l,%d5
	eorl %d5,%a2@+
	.short 0x4a75
	addqw #5,%a4@
	bpls .+57
	moveql #22,%d5
	.short 0x0af1
	moveb %a0@,%a5@+
	.short 0x2ab3
	movew %a2@,%a5@
	.short 0xfd2e
	lslb #6,%d7
	addw %d6,%a4@(-12979:w)
	eorl %d6,%a2@(-21109:w)
	subal %a0@(-29239:w),%a6
	moveql #38,%d6
	bges .+9
	addqw #6,%a4@-
	.short 0x4c45
	movew %a2@-,%a6@
	movel %d3,%a6@
	moveb %a0@-,%a6@+
	.short 0x0cc1
	rolb #7,%d7
	.short 0xff3e
	andw %d7,%a5@+
	.short 0xdf7c
	.short 0xaf9b
	.short 0xbfba
	divsw %a1@+,%d7
	subal 0x6e17:w,%a7
	moveql #54,%d7
	linkw %a5,#0x5e74
	movel %a3@,%a7@
	.short 0x3eb2
	.short 0x0ed1
	.short 0x1ef0
	subql #3,%a3@(256:w)
	btstl %d0,%d0
	orib #97,%d0
	bhis .+101
	bccs .+103
	bnes .+105
	bvcs .+107
	bpls .+109
	bges .+111
	bgts .+113
	moveql #113,%d0
	moveql #115,%d1
	moveql #117,%d2
	moveql #119,%d3
	moveql #121,%d4
	moveql #49,%d5
	.short 0x3233
	.short 0x3435
	movew %a7@(57,%d3:l),%d3
	movew %a5,%d0
	.short 0x1b08
	btstb %d4,%a0@-
	.short 0x2d3d
	subqw #5,%a5@+
	.short 0x5cff
	movew %a7@-,%a5@-
	bras .+46
	movel %a7@(753:w),%d7
	.short 0xf2f3
	.short 0xf4f5
	.short 0xf6f7
	.short 0xf8f9
	.short 0xfafb
	.short 0xfc1f
	.short 0xf0fe
	moveb %a4@,%d4
	.short 0x157f
	moveb %a6@,%a3@-
	moveb %a2@,%a1@-
	moveb %a0@,%a0@-
	btstb %d2,%a7@(10797:w)
	movel %a5,%a5@-
	.short 0x3132
	.short 0x3334
	.short 0x3536
	movew 0x3930:w,%a3@-
	.short 0x2eff
	eorib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #65,%d0
	clrw %d3
	negw %d5
	notw %d7
	.short 0x4849
	.short 0x4a4b
	.short 0x4c4d
	trap #15
	addqw #8,%a1@
	addqw #1,%a3@
	addqw #2,%a5@
	addqw #3,%a7@
	addqw #4,%a1@+
	addqb #5,%a1@-
	negxb %a3@-
	movel %a5@-,%d2
	addqb #7,%a6@-
	movel %a0@(10509:w),%d5
	.short 0x1b08
	btstb %d4,%a0@-
	subqb #7,%a3@(31613:w)
	moveql #-1,%d6
	movew %a2@-,%d5
	moveql #60,%d7
	.short 0x3e3f
	.short 0x02f1
	.short 0xf2f3
	.short 0xf4f5
	.short 0xf6f7
	.short 0xf8f9
	.short 0xfafb
	.short 0xfc1f
	.short 0xf0fe
	moveb %a4@,%d4
	.short 0x157f
	moveb %a6@,%a3@-
	moveb %a2@,%a1@-
	moveb %a0@,%a0@-
	btstb %d2,%a7@(10797:w)
	movel %a5,%a5@-
	.short 0x3132
	.short 0x3334
	.short 0x3536
	movew 0x3930:w,%a3@-
	.short 0x2eff
	eorib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #161,%d0
	.short 0xa2a3
	.short 0xa4a5
	.short 0xa6a7
	.short 0xa8a9
	.short 0xaaab
	.short 0xacad
	.short 0xaeaf
	.short 0xb0b1
	.short 0xb2b3
	.short 0xb4b5
	cmpl %a7@(-71,%a3:l),%d3
	cmpaw %a1@-,%a5
	lsrw %a3@-
	roxrw %a5@-
	rorw %a7@-
	.short 0xe8e9
	lsrb #8,%d7
	.short 0x0008
	orib #0,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #241,%d0
	.short 0xf2f3
	.short 0xf4f5
	.short 0xf6f7
	.short 0xf8f9
	.short 0xfafb
	.short 0xfc00
	orib #0,%d0
	orib #0,%d0
	moveb %a2@,%a1@-
	moveb %a0@,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	.short 0x00c1
	muluw %d3,%d1
	muluw %d5,%d2
	muluw %d7,%d3
	.short 0xc8c9
	.short 0xcacb
	.short 0xcccd
	.short 0xcecf
	addaw %a1@,%a0
	addaw %a3@,%a1
	addaw %a5@,%a2
	addaw %a7@,%a3
	addaw %a1@+,%a4
	.short 0xdabc, 0xbdbe, 0xbfdb
	addaw %a5@+,%a6
	addaw %a7@+,%a7
	cmpmb %a5@+,%a5@+
	.short 0x0008
	orib #0,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #241,%d0
	.short 0xf2f3
	.short 0xf4f5
	.short 0xf6f7
	.short 0xf8f9
	.short 0xfafb
	.short 0xfc00
	orib #0,%d0
	orib #0,%d0
	moveb %a2@,%a1@-
	moveb %a0@,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	oril #-2105310075,%d1
	orl %d7,%d3
	.short 0x8889
	.short 0x8a8b
	.short 0x8c8d
	.short 0x8e8f
	subl %a1@,%d0
	subl %a3@,%d1
	subl %a5@,%d2
	subl %a7@,%d3
	subl %a1@+,%d4
	subl %a4@+,%d5
	subl %d6,%a6@+
	subal %a2@(-5140:w),%a7
	.short 0xedee
	subxb %a5@-,%a5@-
	.short 0x0008
	orib #0,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #241,%d0
	.short 0xf2f3
	.short 0xf4f5
	.short 0xf6f7
	.short 0xf8f9
	.short 0xfafb
	.short 0xfc00
	orib #0,%d0
	orib #0,%d0
	moveb %a2@,%a1@-
	moveb %a0@,%a0@-
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	orib #0,%d0
	.short 0x0000
